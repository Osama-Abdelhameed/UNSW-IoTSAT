options:
  parameters:
    author: sat1
    generate_options: qt_gui
    id: Ground_Station
    output_language: python
    title: Ground_Station
  states: {}

blocks:
- name: Rx_freq_1
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: Rx_freq_2
  id: variable
  parameters:
    value: 917e6
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: variable_constellation_1
  id: variable_constellation
  parameters:
    const_points: '[1, -1]'
    precision: '8'
    sym_map: '[0,1]'
    type: bpsk
  states: {}
- name: CCSDS_sync_word
  id: parameter
  parameters:
    label: sync_word
    value: '"00011010110011111111110000011101"'
  states: {}
- name: Packet_Length
  id: parameter
  parameters:
    value: '241'
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/user/satellite_2/satellite2/sat1.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/sat1/satellite_1/satellite1/sat2.txt
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0_0_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: Tagged Stream to PDU block up ahead needs packed bytes
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_0_0_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: Tagged Stream to PDU block up ahead needs packed bytes
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '1'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '1'
  states: {}
- name: digital_constellation_decoder_cb_1_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_1
  states: {}
- name: digital_constellation_decoder_cb_1_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_1
  states: {}
- name: digital_correlate_access_code_xx_ts_1_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: CCSDS_sync_word
    comment: Correlates with access code to extract the payload.
    tagname: '"packet_len"'
    threshold: '0'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_1_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: CCSDS_sync_word
    comment: Correlates with access code to extract the payload.
    tagname: '"packet_len"'
    threshold: '0'
    type: byte
  states: {}
- name: digital_costas_loop_cc_2_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.00628'
  states: {}
- name: digital_costas_loop_cc_2_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.00628'
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: '0.0628'
    max_dev: '1.5'
    osps: '1'
    sps: '4'
    taps: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
    type: ccf
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: '0.0628'
    max_dev: '1.5'
    osps: '1'
    sps: '4'
    taps: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
    type: ccf
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: samp_rate*4
    center_freq: Rx_freq_1
    dev_args: driver=bladerf,buffer_count=32, buffer_size=16384
    gain: '45.0'
    samp_rate: samp_rate*4
    type: fc32
  states: {}
- name: soapy_bladerf_source_0_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: samp_rate*4
    center_freq: Rx_freq_2
    dev_args: driver=bladerf,buffer_count=32, buffer_size=16384
    gain: '45.0'
    samp_rate: samp_rate*4
    type: fc32
  states: {}

connections:
- [blocks_repack_bits_bb_0_0_0_0_0, '0', digital_crc32_bb_0, '0']
- [blocks_repack_bits_bb_0_0_0_0_0_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', digital_correlate_access_code_xx_ts_1_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0_0, '0', digital_correlate_access_code_xx_ts_1_0_0, '0']
- [digital_constellation_decoder_cb_1_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_1_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_correlate_access_code_xx_ts_1_0, '0', blocks_repack_bits_bb_0_0_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_1_0_0, '0', blocks_repack_bits_bb_0_0_0_0_0_0, '0']
- [digital_costas_loop_cc_2_0, '0', digital_constellation_decoder_cb_1_0, '0']
- [digital_costas_loop_cc_2_0_0, '0', digital_constellation_decoder_cb_1_0_0, '0']
- [digital_crc32_bb_0, '0', blocks_file_sink_0_0_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_file_sink_0_0_0_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [digital_diff_decoder_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_2_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', digital_costas_loop_cc_2_0_0, '0']
- [soapy_bladerf_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [soapy_bladerf_source_0_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
